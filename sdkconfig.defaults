## sdkconfig.defaults
```kconfig
CONFIG_IDF_CMAKE=n
CONFIG_FREERTOS_WATCHPOINT_END_OF_STACK=y
CONFIG_FREERTOS_SUPPORT_STATIC_ALLOCATION=y
```
